<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>event_example</value></param>
<param><key>author</key><value>Glen Langston</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>c++ block test</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>event_example</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Bandwidth</value></param>
<param><key>value</key><value>2e6</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>Mode</value></param>
<param><key>value</key><value>2</value></param>
<param><key>label0</key><value>Monitor</value></param>
<param><key>label1</key><value>Detect</value></param>
<param><key>label</key><value>Mode</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>1</value></param>
<param><key>option1</key><value>2</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fftsize</value></param>
<param><key>value</key><value>1024</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>705e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ndm</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nt</value></param>
<param><key>value</key><value>512</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>10e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>vec_length</value></param>
<param><key>value</key><value>512</value></param>
</block>
<block>
<key>analog_fastnoise_source_x</key>
<param><key>id</key><value>analog_fastnoise_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>samples</key><value>8192</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>Bandwidth/fftsize</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fftsize</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>fftsize</value></param>
<param><key>srate</key><value>Bandwidth</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>radio_astro_event</key>
<param><key>id</key><value>radio_astro_event_0</value></param>
<param><key>bw_hz</key><value>Bandwidth</value></param>
<param><key>dt</key><value>.001</value></param>
<param><key>mode</key><value>Mode</value></param>
<param><key>n_sigma</key><value>3.6</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<connection><source_block_id>analog_fastnoise_source_x_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0</source_block_id><sink_block_id>radio_astro_event_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radio_astro_event_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
